options:
  parameters:
    author: Marcello Bullo
    category: Custom
    description: OFDM image receiver for deep joint source channel coding (DJSCC)
    generate_options: qt_gui
    id: djscc_rx
    output_language: python
    title: OFDM Image Receiver for DJSCC
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter_rx
  id: variable
  parameters:
    value: deepjscc.packet_header_ofdm_wide(occupied_carriers, n_syms=1, len_tag_key="packet_len",   frame_len_tag_key="frame_len", num_tag_key="packet_num", bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=8, scramble_header=True,  expected_packet_len=packet_len)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '960'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_static(fft_len, occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: receiver_gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      Mini-Mini: 40
      USRP-Mini: 25
    rangeType: int
    start: '0'
    step: '5'
    stop: '70'
    value: '20'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: band
  id: parameter
  parameters:
    label: Band
    type: eng_float
    value: 5e6
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Adds 80 0s infront
    delay: fft_len+int(fft_len/4)
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: carrier_freq
  id: parameter
  parameters:
    label: Carrier Frequency
    type: eng_float
    value: 2.45e9
  states: {}
- name: device_address
  id: parameter
  parameters:
    label: 'Device IP address '
    type: str
    value: '"192.168.1.68"'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    comment: |-
      Items: Complex symbols
      Symbols: OFDM symbols
    guard_interval: int(fft_len/4)
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: '"frame_len"'
    minoutbuf: '2000000'
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_ofdm_chanest_vcvc_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: int(fft_len/4)
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_1
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: int(fft_len/4)
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: '"frame_len"'
    maxoutbuf: '1048576'
    minoutbuf: '1048576'
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_header
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_payload
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: '"frame_len"'
    occupied_carriers: occupied_carriers
    packet_len_tag_key: '"packet_len"'
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    comment: Triggers at sample 80
    cp_len: int(fft_len/4)
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_packet_headerparser_b_0_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter_rx.base()
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '100'
    type: '0'
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: import_deepjscc
  id: import
  parameters:
    imports: from gnuradio import deepjscc
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"RX"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"HEADER RX"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_RX
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Raw RX IQ PSD (pre-sync)
    fc: carrier_freq
    fftsize: '1024'
    name: '"RX Raw IQ PSD"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_RX
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Raw RX IQ waterfall (pre-sync) for spectrum monitoring
    fc: carrier_freq
    fftsize: '1024'
    name: '"RX Raw IQ"'
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Frequency
    type: eng_float
    value: 1e6
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: band
    center_freq0: carrier_freq
    dev_addr: '"addr="+device_address'
    gain0: receiver_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    comment: 2xSync(128)+1H(64) = 192
    stream_id: Header Stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Payload Stream
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '100'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5561
    timeout: '100'
    type: complex
    vlen: '64'
  states: {state: disabled}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', virtual_sink_1_0_0, '0']
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_packet_headerparser_b_0_0, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_0_1, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_1, '0']
- [digital_ofdm_chanest_vcvc_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_header, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', digital_ofdm_serializer_vcc_payload, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', zeromq_push_sink_0, '0']
- [digital_ofdm_serializer_vcc_header, '0', digital_constellation_decoder_cb_0, '0']
- [digital_ofdm_serializer_vcc_header, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [digital_ofdm_serializer_vcc_header, '0', qtgui_const_sink_x_0_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', blocks_multiply_const_vxx_0_1, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [digital_packet_headerparser_b_0_0, header_data, digital_header_payload_demux_0, header_data]
- [digital_probe_mpsk_snr_est_c_0, snr, blocks_message_debug_0, log]
- [digital_probe_mpsk_snr_est_c_0, snr, blocks_message_debug_0, print]
- [fft_vxx_0_0, '0', digital_ofdm_chanest_vcvc_0, '0']
- [fft_vxx_1, '0', digital_ofdm_frame_equalizer_vcvc_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, zeromq_pub_msg_sink_0, in]
- [pdu_tagged_stream_to_pdu_0, pdus, zeromq_push_msg_sink_0, in]
- [uhd_usrp_source_0_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0_RX, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0_RX, '0']
- [virtual_source_0_1, '0', fft_vxx_0_0, '0']
- [virtual_source_1_0, '0', fft_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
