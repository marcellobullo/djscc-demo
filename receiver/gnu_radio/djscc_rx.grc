options:
  parameters:
    author: Marcello Bullo
    category: Custom
    description: OFDM image receiver for deep joint source channel coding (DJSCC)
    generate_options: qt_gui
    id: djscc_rx
    output_language: python
    title: OFDM Image Receiver for DJSCC
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter_rx
  id: variable
  parameters:
    value: deepjscc.packet_header_ofdm_wide(occupied_carriers, n_syms=1, len_tag_key="packet_len",   frame_len_tag_key="frame_len", num_tag_key="packet_num", bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=8, scramble_header=True,  expected_packet_len=packet_len)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '960'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_static(fft_len, occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: receiver_gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      Mini-Mini: 40
      USRP-Mini: 25
    rangeType: int
    start: '0'
    step: '5'
    stop: '70'
    value: '20'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: band
  id: parameter
  parameters:
    label: Band
    type: eng_float
    value: 5e6
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Adds 80 0s infront
    delay: fft_len+int(fft_len/4)
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: carrier_freq
  id: parameter
  parameters:
    label: Carrier Frequency
    type: eng_float
    value: 2.45e9
  states: {}
- name: chan_taps_logger_0
  id: epy_block
  parameters:
    _source_code: |
      """Header-gated channel-tap logger with packet_len validation."""

      import threading
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, fft_len=64, packet_len=960,
                       out_path='/tmp/h_dataset.npz', flush_every=200):
              gr.sync_block.__init__(
                  self,
                  name='chan_taps_logger',
                  in_sig=[(np.complex64, fft_len)],
                  out_sig=[(np.complex64, fft_len)],
              )
              self.fft_len = int(fft_len)
              self.packet_len = int(packet_len)
              self.out_path = str(out_path)
              self.flush_every = int(flush_every)
              self.tag_key = pmt.intern('ofdm_sync_chan_taps')
              self.pkt_num_key = pmt.intern('packet_num')
              self.pkt_len_key = pmt.intern('packet_len')
              self.pending = []
              self.max_pending = 8
              self.pn_list = []
              self.h_list = []
              self.n_rejected = 0
              self._lock = threading.Lock()
              self.msg_port = pmt.intern('header_valid')
              self.message_port_register_in(self.msg_port)
              self.set_msg_handler(self.msg_port, self._on_header_valid)
              self.snr_part_port = pmt.intern('snr_part')
              self.message_port_register_out(self.snr_part_port)

          def _extract_int(self, msg, key):
              sentinel = pmt.from_long(-(1 << 30))
              candidates = [msg]
              try:
                  if pmt.is_pair(msg):
                      candidates.append(pmt.car(msg))
              except Exception:
                  pass
              for cand in candidates:
                  try:
                      val = pmt.dict_ref(cand, key, sentinel)
                      if not pmt.equal(val, sentinel):
                          return pmt.to_long(val)
                  except Exception:
                      continue
              return None

          def _on_header_valid(self, msg):
              pl = self._extract_int(msg, self.pkt_len_key)
              pn = self._extract_int(msg, self.pkt_num_key)
              if pl != self.packet_len or pn is None or pn < 0 or pn >= (1 << 24):
                  self.n_rejected += 1
                  return
              with self._lock:
                  if not self.pending:
                      return
                  h_finalized = self.pending[-1]
                  self.h_list.append(h_finalized)
                  self.pn_list.append(int(pn))
                  self.pending.clear()
                  if len(self.pn_list) % self.flush_every == 0:
                      self._flush()
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('packet_num'), pmt.from_long(int(pn)))
              meta = pmt.dict_add(meta, pmt.intern('kind'), pmt.intern('h'))
              payload = pmt.init_c32vector(self.fft_len, h_finalized.tolist())
              self.message_port_pub(self.snr_part_port, pmt.cons(meta, payload))

          def _flush(self):
              if not self.pn_list:
                  return
              np.savez(self.out_path,
                       packet_num=np.array(self.pn_list, dtype=np.int64),
                       h=np.array(self.h_list, dtype=np.complex64))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              out0[:] = in0
              n = len(in0)
              for tag in self.get_tags_in_window(0, 0, n, self.tag_key):
                  taps = np.array(pmt.c32vector_elements(tag.value), dtype=np.complex64)
                  with self._lock:
                      self.pending.append(taps)
                      if len(self.pending) > self.max_pending:
                          self.pending = self.pending[-self.max_pending:]
              return n

          def stop(self):
              with self._lock:
                  self._flush()
              print('[chan_taps_logger] committed=%d rejected=%d -> %s'
                    % (len(self.pn_list), self.n_rejected, self.out_path))
              return True
    comment: Logs per-frame (packet_num, h) to .npz (header-gated, packet_len validated)
    fft_len: fft_len
    flush_every: '200'
    out_path: '"/tmp/h_dataset.npz"'
    packet_len: packet_len
  states: {}
- name: device_address
  id: parameter
  parameters:
    label: 'Device IP address '
    type: str
    value: '"192.168.1.67"'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    comment: |-
      Items: Complex symbols
      Symbols: OFDM symbols
    guard_interval: int(fft_len/4)
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: '"frame_len"'
    minoutbuf: '2000000'
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_ofdm_chanest_vcvc_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: int(fft_len/4)
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_1
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: int(fft_len/4)
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: '"frame_len"'
    maxoutbuf: '1048576'
    minoutbuf: '1048576'
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_header
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_payload
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: '"frame_len"'
    occupied_carriers: occupied_carriers
    packet_len_tag_key: '"packet_len"'
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    comment: Triggers at sample 80
    cp_len: int(fft_len/4)
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_packet_headerparser_b_0_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter_rx.base()
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '100'
    type: '0'
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: import_deepjscc
  id: import
  parameters:
    imports: from gnuradio import deepjscc
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: complex
  states: {}
- name: pilot_phase_track_0
  id: epy_block
  parameters:
    _source_code: |
      """Per-OFDM-symbol pilot-based phase de-rotation with a coherence gate.

      Sits between digital_ofdm_frame_equalizer_vcvc_1 (static payload equalizer,
      no pilot tracking) and the payload serializer + pilot_snr_logger. For each
      input OFDM vector this block:

        1. Extracts the 4 pilot subcarriers.
        2. Computes  est = mean(pilot_received * conj(pilot_expected))
           whose phase is the residual rotation of that OFDM symbol.
        3. ONLY applies a per-symbol phase derotation when |est| is close to its
           ideal unit magnitude — i.e. when the four pilots agree. If pilots are
           noise-dominated (e.g. pilot subcarriers fall in a frequency-selective
           fade) the phase estimate is unreliable, and applying it would *add*
           random rotations rather than remove drift. In that case the block is a
           strict pass-through. This guarantees the block never makes the signal
           worse than the static-EQ baseline.

      A diagnostic line is printed every `log_every` OFDM symbols reporting the
      fraction actually corrected and the mean |est|. If mean |est| sits well
      below 1, the pilots in this channel are too noisy for per-symbol tracking
      and the fix needs to live elsewhere (e.g. MMSE equalization, or moving
      pilots off a fade).

      This is NOT decision-feedback equalization: continuous-valued DJSCC
      symbols pass through with unchanged modulus.
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, fft_len=64,
                       pilot_positions=[11, 25, 39, 53],
                       pilot_symbols=[1.0, 1.0, 1.0, -1.0],
                       coh_thresh=0.5,
                       log_every=4096):
              gr.sync_block.__init__(
                  self,
                  name='pilot_phase_track',
                  in_sig=[(np.complex64, fft_len)],
                  out_sig=[(np.complex64, fft_len)],
              )
              self.pilot_positions = np.array(pilot_positions, dtype=np.int64)
              self.pilot_symbols = np.array(pilot_symbols, dtype=np.complex64)
              self.pilot_conj = np.conj(self.pilot_symbols).astype(np.complex64)
              self.coh_thresh = float(coh_thresh)
              self.log_every = int(log_every)
              self._n_seen = 0
              self._n_corrected = 0
              self._mag_sum = 0.0

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n = len(in0)
              if n == 0:
                  return 0
              pilots = in0[:, self.pilot_positions]
              cross = pilots * self.pilot_conj[None, :]
              est = cross.mean(axis=1)
              mag = np.abs(est)
              safe = mag > self.coh_thresh
              correction = np.ones(n, dtype=np.complex64)
              if np.any(safe):
                  correction[safe] = (est[safe].conj()
                                      / np.maximum(mag[safe], 1e-9)
                                      ).astype(np.complex64)
              out0[:] = (in0 * correction[:, None]).astype(np.complex64)
              self._n_seen += n
              self._n_corrected += int(safe.sum())
              self._mag_sum += float(mag.sum())
              if self._n_seen >= self.log_every:
                  mean_mag = self._mag_sum / max(self._n_seen, 1)
                  ratio = self._n_corrected / max(self._n_seen, 1)
                  print('[pilot_phase_track] last %d syms: corrected %.0f%% | '
                        'mean |est|=%.3f (gate=%.2f)'
                        % (self._n_seen, ratio * 100.0, mean_mag, self.coh_thresh))
                  self._n_seen = 0
                  self._n_corrected = 0
                  self._mag_sum = 0.0
              return n
    coh_thresh: '0.5'
    comment: Per-OFDM-symbol pilot phase derotation (fixes residual CFO/SCO drift)
    fft_len: fft_len
    log_every: '4096'
    pilot_positions: '[11, 25, 39, 53]'
    pilot_symbols: '[1.0, 1.0, 1.0, -1.0]'
  states: {state: disabled}
- name: pilot_snr_logger_0
  id: epy_block
  parameters:
    _source_code: |
      """Per-frame equalized-pilot logger for offline SNR estimation."""

      import threading
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, fft_len=64,
                       pilot_positions=[11, 25, 39, 53],
                       pilot_symbols=[1.0, 1.0, 1.0, -1.0],
                       out_path='/tmp/pilot_dataset.npz',
                       flush_every=200):
              gr.sync_block.__init__(
                  self,
                  name='pilot_snr_logger',
                  in_sig=[(np.complex64, fft_len)],
                  out_sig=None,
              )
              self.fft_len = int(fft_len)
              self.pilot_positions = np.array(pilot_positions, dtype=np.int64)
              self.pilot_symbols = np.array(pilot_symbols, dtype=np.complex64)
              self.out_path = str(out_path)
              self.flush_every = int(flush_every)
              self.pkt_num_key = pmt.intern('packet_num')
              self.frame_len_key = pmt.intern('frame_len')

              self._curr_pn = None
              self._curr_fl = 0
              self._curr_consumed = 0
              self._curr_pilots = []

              self.pn_list = []
              self.mean_pilots_list = []
              self.sigma2_list = []
              self._lock = threading.Lock()
              self.snr_part_port = pmt.intern('snr_part')
              self.message_port_register_out(self.snr_part_port)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              n = len(in0)
              nread = self.nitems_read(0)

              tag_map = {}
              for tag in self.get_tags_in_window(0, 0, n, self.pkt_num_key):
                  tag_map.setdefault(int(tag.offset - nread), {})['pn'] = pmt.to_long(tag.value)
              for tag in self.get_tags_in_window(0, 0, n, self.frame_len_key):
                  tag_map.setdefault(int(tag.offset - nread), {})['fl'] = pmt.to_long(tag.value)

              for i in range(n):
                  if i in tag_map:
                      self._finalize_frame()
                      info = tag_map[i]
                      self._curr_pn = info.get('pn')
                      self._curr_fl = info.get('fl', 0)
                      self._curr_consumed = 0
                      self._curr_pilots = []
                  if self._curr_pn is not None and self._curr_consumed < self._curr_fl:
                      self._curr_pilots.append(in0[i][self.pilot_positions])
                      self._curr_consumed += 1
                      if self._curr_consumed >= self._curr_fl:
                          self._finalize_frame()
              return n

          def _finalize_frame(self):
              if self._curr_pn is None or not self._curr_pilots:
                  self._curr_pn = None
                  self._curr_pilots = []
                  self._curr_consumed = 0
                  self._curr_fl = 0
                  return
              arr = np.array(self._curr_pilots, dtype=np.complex64)
              mean_p = arr.mean(axis=0)
              n_eq = arr - self.pilot_symbols[None, :]
              sigma2 = float(np.mean(np.abs(n_eq) ** 2))
              pn_finalized = int(self._curr_pn)
              with self._lock:
                  self.pn_list.append(pn_finalized)
                  self.mean_pilots_list.append(mean_p)
                  self.sigma2_list.append(sigma2)
                  if len(self.pn_list) % self.flush_every == 0:
                      self._flush()
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('packet_num'), pmt.from_long(pn_finalized))
              meta = pmt.dict_add(meta, pmt.intern('kind'), pmt.intern('pilots'))
              meta = pmt.dict_add(meta, pmt.intern('sigma2'), pmt.from_double(sigma2))
              self.message_port_pub(self.snr_part_port, pmt.cons(meta, pmt.PMT_NIL))
              self._curr_pn = None
              self._curr_pilots = []
              self._curr_consumed = 0
              self._curr_fl = 0

          def _flush(self):
              if not self.pn_list:
                  return
              np.savez(self.out_path,
                       packet_num=np.array(self.pn_list, dtype=np.int64),
                       mean_pilots=np.array(self.mean_pilots_list, dtype=np.complex64),
                       sigma2=np.array(self.sigma2_list, dtype=np.float32))

          def stop(self):
              with self._lock:
                  self._flush()
              print('[pilot_snr_logger] saved %d frames -> %s'
                    % (len(self.pn_list), self.out_path))
              return True
    comment: Per-frame equalized pilot logger for SNR estimation
    fft_len: fft_len
    flush_every: '200'
    out_path: '"/tmp/pilot_dataset.npz"'
    pilot_positions: '[11, 25, 39, 53]'
    pilot_symbols: '[1.0, 1.0, 1.0, -1.0]'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"RX"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"HEADER RX"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_RX
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Raw RX IQ PSD (pre-sync)
    fc: carrier_freq
    fftsize: '1024'
    name: '"RX Raw IQ PSD"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_RX
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Raw RX IQ waterfall (pre-sync) for spectrum monitoring
    fc: carrier_freq
    fftsize: '1024'
    name: '"RX Raw IQ"'
    type: complex
  states: {}
- name: raw_noise_logger_0
  id: epy_block
  parameters:
    _source_code: |
      import threading
      import numpy as np
      import pmt
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, fft_len=64, null_positions=[0, 1, 2, 3, 4, 5, 59, 60, 61, 62, 63], out_path='/tmp/raw_noise_dataset.npz', flush_every=200):
              gr.sync_block.__init__(self, name='raw_noise_logger', in_sig=[(np.complex64, fft_len)], out_sig=None)
              self.fft_len = int(fft_len)
              self.null_positions = np.array(null_positions, dtype=np.int64)
              self.out_path = str(out_path)
              self.flush_every = int(flush_every)
              self.pkt_num_key = pmt.intern('packet_num')
              self.frame_len_key = pmt.intern('frame_len')
              self._curr_pn = None
              self._curr_fl = 0
              self._curr_consumed = 0
              self._curr_noise_pwrs = []
              self.pn_list = []
              self.sigma2_list = []
              self._lock = threading.Lock()
              self.snr_part_port = pmt.intern('snr_part')
              self.message_port_register_out(self.snr_part_port)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              n = len(in0)
              nread = self.nitems_read(0)
              tag_map = {}
              for tag in self.get_tags_in_window(0, 0, n, self.pkt_num_key):
                  tag_map.setdefault(int(tag.offset - nread), {})['pn'] = pmt.to_long(tag.value)
              for tag in self.get_tags_in_window(0, 0, n, self.frame_len_key):
                  tag_map.setdefault(int(tag.offset - nread), {})['fl'] = pmt.to_long(tag.value)

              for i in range(n):
                  if i in tag_map:
                      self._finalize_frame()
                      info = tag_map[i]
                      self._curr_pn = info.get('pn')
                      self._curr_fl = info.get('fl', 0)
                      self._curr_consumed = 0
                      self._curr_noise_pwrs = []
                  if self._curr_pn is not None and self._curr_consumed < self._curr_fl:
                      null_syms = in0[i][self.null_positions]
                      self._curr_noise_pwrs.append(np.mean(np.abs(null_syms)**2))
                      self._curr_consumed += 1
                      if self._curr_consumed >= self._curr_fl:
                          self._finalize_frame()
              return n

          def _finalize_frame(self):
              if self._curr_pn is None or not self._curr_noise_pwrs:
                  self._curr_pn = None
                  self._curr_noise_pwrs = []
                  self._curr_consumed = 0
                  self._curr_fl = 0
                  return
              avg_sigma2 = float(np.mean(self._curr_noise_pwrs))
              pn_finalized = int(self._curr_pn)
              with self._lock:
                  self.pn_list.append(pn_finalized)
                  self.sigma2_list.append(avg_sigma2)
                  if len(self.pn_list) % self.flush_every == 0:
                      self._flush()
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('packet_num'), pmt.from_long(pn_finalized))
              meta = pmt.dict_add(meta, pmt.intern('kind'), pmt.intern('raw'))
              meta = pmt.dict_add(meta, pmt.intern('sigma2'), pmt.from_double(avg_sigma2))
              self.message_port_pub(self.snr_part_port, pmt.cons(meta, pmt.PMT_NIL))
              self._curr_pn = None
              self._curr_noise_pwrs = []
              self._curr_consumed = 0
              self._curr_fl = 0

          def _flush(self):
              if not self.pn_list:
                  return
              np.savez(self.out_path, packet_num=np.array(self.pn_list, dtype=np.int64), sigma2=np.array(self.sigma2_list, dtype=np.float32))

          def stop(self):
              with self._lock:
                  self._flush()
              print('[raw_noise_logger] saved %d frames -> %s' % (len(self.pn_list), self.out_path))
              return True
    comment: Logs pre-equalization noise from null subcarriers
    fft_len: fft_len
    flush_every: '200'
    null_positions: '[0, 1, 2, 3, 4, 5, 59, 60, 61, 62, 63]'
    out_path: '"/tmp/raw_noise_dataset.npz"'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Frequency
    type: eng_float
    value: 1e6
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: band
    center_freq0: carrier_freq
    dev_addr: '"addr="+device_address'
    gain0: receiver_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    comment: 2xSync(128)+1H(64) = 192
    stream_id: Header Stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Payload Stream
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5560
    timeout: '100'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5561
    timeout: '100'
    type: complex
    vlen: '64'
  states: {state: disabled}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', virtual_sink_1_0_0, '0']
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0, '0']
- [chan_taps_logger_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [chan_taps_logger_0, snr_part, zeromq_push_msg_sink_1, in]
- [digital_constellation_decoder_cb_0, '0', digital_packet_headerparser_b_0_0, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_0_1, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_1, '0']
- [digital_ofdm_chanest_vcvc_0, '0', chan_taps_logger_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_header, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', digital_ofdm_serializer_vcc_payload, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', pilot_snr_logger_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', zeromq_push_sink_0, '0']
- [digital_ofdm_serializer_vcc_header, '0', digital_constellation_decoder_cb_0, '0']
- [digital_ofdm_serializer_vcc_header, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [digital_ofdm_serializer_vcc_header, '0', qtgui_const_sink_x_0_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', blocks_multiply_const_vxx_0_1, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [digital_packet_headerparser_b_0_0, header_data, chan_taps_logger_0, header_valid]
- [digital_packet_headerparser_b_0_0, header_data, digital_header_payload_demux_0, header_data]
- [digital_probe_mpsk_snr_est_c_0, snr, blocks_message_debug_0, log]
- [digital_probe_mpsk_snr_est_c_0, snr, blocks_message_debug_0, print]
- [fft_vxx_0_0, '0', digital_ofdm_chanest_vcvc_0, '0']
- [fft_vxx_1, '0', digital_ofdm_frame_equalizer_vcvc_1, '0']
- [fft_vxx_1, '0', raw_noise_logger_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, zeromq_pub_msg_sink_0, in]
- [pdu_tagged_stream_to_pdu_0, pdus, zeromq_push_msg_sink_0, in]
- [pilot_snr_logger_0, snr_part, zeromq_push_msg_sink_1, in]
- [raw_noise_logger_0, snr_part, zeromq_push_msg_sink_1, in]
- [uhd_usrp_source_0_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0_RX, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0_RX, '0']
- [virtual_source_0_1, '0', fft_vxx_0_0, '0']
- [virtual_source_1_0, '0', fft_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
