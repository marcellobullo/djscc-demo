options:
  parameters:
    category: Custom
    description: OFDM transmitter for conventional separated source-channel coding (SSCC)
    generate_options: qt_gui
    id: conventional_tx
    output_language: python
    run_options: run
    title: OFDM Transmitter for Conventional SSCC
  states: {}

blocks:
- name: band
  id: variable
  parameters:
    comment: |-
      0 for adaptive bandwith allocation

      5Mhz previsouly used
    value: '5000000'
  states: {state: disabled}
- name: carrier_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {state: disabled}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: mod_order
  id: variable
  parameters:
    comment: |-
      Single source of truth for modulation:
      1 --> BPSK,  2 --> QPSK,  4 --> 16QAM.
      `repack` and `payload_mod` derive from this.
      Must match --bits-per-symbol on the python TX.
    value: '2'
  states: {state: disabled}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '960'
  states: {}
- name: packet_length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_mod
  id: variable
  parameters:
    comment: derived from mod_order (1=BPSK, 2=QPSK, 4=16QAM)
    value: '{1: digital.constellation_bpsk(), 2: digital.constellation_qpsk(), 4: digital.constellation_16qam()}[mod_order]'
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {state: disabled}
- name: sync_word1
  id: variable
  parameters:
    comment: |-
      64 samples
      Starts/Ends with 6 0s
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    comment: |-
      64 samples
      Ends with 5 0s
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      Mini-Mini: 35
      USRP-Mini: 0
    start: '0'
    step: '8'
    stop: '70'
    value: '18'
  states: {}
- name: band
  id: parameter
  parameters:
    label: Band
    type: eng_float
    value: 5e6
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.03'
    maxoutbuf: '2000000'
    minoutbuf: '2000000'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: mod_order
    len_tag_key: ''
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: the next 960 items are one packet
    len_tag_key: '"packet_len"'
    maxoutbuf: '2000000'
    minoutbuf: '2000000'
    packet_len: packet_len*mod_order//8
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: the next 960 items are one packet
    len_tag_key: '"packet_len"'
    maxoutbuf: '2000000'
    minoutbuf: '2000000'
    packet_len: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: complex
  states: {}
- name: carrier_freq
  id: parameter
  parameters:
    label: Carrier Frequency
    type: eng_float
    value: 2.45e9
  states: {}
- name: device_address
  id: parameter
  parameters:
    label: 'Device IP address '
    type: str
    value: '"192.168.1.68"'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: 17472 complex symbols
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    comment: |-
      Sync1 (1*64) + Sync2(1*64) = 128
      Header (1*64) = 64
      Payload(22*64) = 1408
      Total = 25 symbols or 1600 samples
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    comment: |-
      64+16 = 80
      25 symbols *80 = 2000
    cp_len: int(fft_len/4)
    input_size: fft_len
    tagname: length_tag_key
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    comment: 'Samples: 48'
    header_formatter: deepjscc.packet_header_ofdm_wide(occupied_carriers, n_syms=1, len_tag_key="packet_len",   frame_len_tag_key=length_tag_key, num_tag_key="packet_num", bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=8, scramble_header=True, expected_packet_len=packet_len)
    len_tag_key: '"packet_len"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: window.blackmanharris(64)
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: header_bits
  id: virtual_sink
  parameters:
    stream_id: Header Bits
  states: {}
- name: import_deepjscc
  id: import
  parameters:
    imports: from gnuradio import deepjscc
  states: {}
- name: import_deepjscc_0
  id: import
  parameters:
    imports: import os, math
  states: {}
- name: mod_order
  id: parameter
  parameters:
    label: Bits Per Modulation Symbol
    value: '2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"Transmitted Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_1
  id: qtgui_time_sink_x
  parameters:
    label1: Re
    label2: Im
    name: '"TX: After-OFDM"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
  states: {}
- name: qtgui_time_sink_x_0_1_1_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Re
    label2: Im
    name: '"TX: after tag "'
    size: int(packet_len*5.1)
    srate: samp_rate
    type: complex
    width1: '2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"After-OFDM"'
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Frequency
    type: eng_float
    value: 1e6
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: band
    center_freq0: carrier_freq
    dev_addr: '"addr="+device_address'
    gain0: tx_gain
    len_tag_name: '"packet_len"'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    comment: Used to pass the tag
    stream_id: Tag Parse
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Bits
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Tag Parse
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5557
    comment: |-
      Conventional baseline:
      bytes from image_tx_encoded_conventional.py
    hwm: '5000'
    maxoutbuf: '2000000'
    minoutbuf: '2000000'
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_float_to_uchar_0, '0', digital_packet_headergenerator_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', qtgui_const_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', qtgui_time_sink_x_0_1_1_0_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', virtual_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', virtual_sink_0_0_1, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_packet_headergenerator_bb_0, '0', header_bits, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [virtual_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_1, '0', blocks_complex_to_real_0, '0']
- [zeromq_sub_source_0, '0', blocks_repack_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
